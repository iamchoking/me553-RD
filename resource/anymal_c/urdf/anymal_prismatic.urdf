Commit message: fin-prep finish-up

File: resource/anymal_c/urdf/anymal_prismatic.urdf (robot description, URDF)
Before this commit: robot anymal, 78 links, 77 joints
Joints:
- joint LF_KFE: type revolute -> prismatic
- joint RF_HFE: type revolute -> prismatic
